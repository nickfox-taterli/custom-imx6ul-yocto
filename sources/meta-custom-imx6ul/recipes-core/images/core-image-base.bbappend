IMAGE_INSTALL += "imx-kobs \
    net-tools \
    ethtool \
    udev-extraconf \
    rpm \
    openssh \
    openssl \
    vsftpd \
    u-boot-fw-utils \
    mmc-utils \
    util-linux-sfdisk \
    e2fsprogs-mke2fs \
    e2fsprogs-resize2fs \
    mtd-utils-ubifs \
    u-boot-custom \
    rc-local"
